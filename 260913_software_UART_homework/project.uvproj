# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c delay.h digital_tube.c digital_tube.h main.c timer0.c timer0.h UART_Receiver.c UART_Transmitter.c UART_Receiver.h UART_Transmitter.h
