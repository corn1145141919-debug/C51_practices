# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c digital_tube.c main.c matrixButton.c timer0.c delay.h digital_tube.h matrixButton.h timer0.h expression_receiver.c expression_solver.c token.c expression_receiver.h expression_solver.h token.h
